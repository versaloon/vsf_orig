# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __TARGET_CHIP__=nuc400
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\; ..\..\vsf_cfg; ..\..\..\..\compiler\IAR; ..\..\..\..\interfaces; ..\..\..\..\tool\list; ..\..\..\..\interfaces\cpu\nuc400; ..\..\..\..\interfaces\cpu\nuc400\core; ..\..\..\..\stack\usb\host\; ..\..\..\..\stack\usb\host\hcd\ohci
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: nuc442.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: main.c
  group vsf/dal/mal
    ../../../../dal/mal/: mal.c
  group vsf/dal/stream
    ../../../../dal/stream/: stream.c
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/interfaces
    ../../../../interfaces/: interfaces.c
  group vsf/interfaces/cpu/nuc400
    ../../../../interfaces/cpu/nuc400/: core.c
    ../../../../interfaces/cpu/nuc400/core/: retarget.c
  group vsf/interfaces/cpu/nuc400/gpio
    ../../../../interfaces/cpu/nuc400/gpio/: NUC400_GPIO.c
  group vsf/interfaces/cpu/nuc400/startup
    ../../../../interfaces/cpu/nuc400/startup/IAR/: startup_NUC472_442.s
  group vsf/interfaces/cpu/nuc400/usbd
    ../../../../interfaces/cpu/nuc400/usbd/: NUC400_USBD.c
  group vsf/interfaces/cpu/stm32
    ../../../../interfaces/cpu/stm32/: core.c
  group vsf/interfaces/cpu/stm32/adc
    ../../../../interfaces/cpu/stm32/adc/: STM32_ADC.c
  group vsf/interfaces/cpu/stm32/ebi
    ../../../../interfaces/cpu/stm32/ebi/: STM32_EBI.c
  group vsf/interfaces/cpu/stm32/eint
    ../../../../interfaces/cpu/stm32/eint/: STM32_EINT.c
  group vsf/interfaces/cpu/stm32/flash
    ../../../../interfaces/cpu/stm32/flash/: STM32_FLASH.c
  group vsf/interfaces/cpu/stm32/gpio
    ../../../../interfaces/cpu/stm32/gpio/: STM32_GPIO.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver/src/: usb_mem.c usb_regs.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver
    ../../../../interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
  group vsf/interfaces/cpu/stm32/sdio
    ../../../../interfaces/cpu/stm32/sdio/: STM32_SDIO.c
  group vsf/interfaces/cpu/stm32/spi
    ../../../../interfaces/cpu/stm32/spi/: STM32_SPI.c
  group vsf/interfaces/cpu/stm32/timer
    ../../../../interfaces/cpu/stm32/timer/: STM32_TIM.c
  group vsf/interfaces/cpu/stm32/usart
    ../../../../interfaces/cpu/stm32/usart/: STM32_USART.c
  group vsf/interfaces/cpu/stm32/usbd
    ../../../../interfaces/cpu/stm32/usbd/: STM32_USBD.c
  group vsf/stack/usb/device
    ../../../../stack/usb/device/: vsfusbd.c
  group vsf/stack/usb/device/class/CDC
    ../../../../stack/usb/device/class/CDC/: vsfusbd_CDC.c vsfusbd_CDCACM.c
  group vsf/stack/usb/device/class/HID
    ../../../../stack/usb/device/class/HID/: vsfusbd_HID.c
  group vsf/tool/buffer
    ../../../../tool/buffer/: buffer.c
  group vsf/tool/fakefat32
    ../../../../tool/fakefat32/: fakefat32.c
  group vsf/tool/list
    ../../../../tool/list/: list.c list.h
  group vsf/tool/mal_embflash
    ../../../../tool/mal_embflash/: mal_embflash.c
  group vsf/tool/mal_in_mal
    ../../../../tool/mal_in_mal/: mal_in_mal.c
  group vsf_cfg
    ../../vsf_cfg/: dal_cfg.h vsfsm_cfg.h vsfusbd_cfg.h
  group vsfshell
    ../../vsfshell/: vsfshell.c
