# IAR project scsi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: VSF_STANDALONE_MODULE; MODULE_NAME="vsf.component.mal.scsi"; MODULE_INIT=vsfscsi_modinit; MODULE_EXIT=vsfscsi_modexit
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\cortex-m
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: MODULE_SIZE=0x1000; MODULE_NAME="vsf.component.mal.scsi"
  OBJCOPY.OOCOutputFile: scsi.bin
  postbuild: wscript "fixsize.vbs" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: scsi.out
  ILINK.IlinkIcfFile: module.icf
  ILINK.IlinkProgramEntryLabel: module_entry
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; VSF_STANDALONE_MODULE; MODULE_NAME="vsf.component.mal.scsi"; MODULE_INIT=vsfscsi_modinit; MODULE_EXIT=vsfscsi_modexit
  group (top)
    ./: app_cfg.h interfaces_cfg.h vsf_cfg.h
    ../../: app_hw_cfg.h
    ../../module/: modmain.c
  group vsf/component/mal
    ../../../../component/mal/: vsfscsi.c
  group vsf/interfaces/cpu/cortex-m/startup
    ../../../../interfaces/cpu/cortex-m/startup/iar/: startup.s
