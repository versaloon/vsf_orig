<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app_blink.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\app_helloworld.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\debug.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dhcpc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dhcpd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dnsc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\embflash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\fakefat32.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\fat.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\file.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\httpc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\httpd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mal.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\malfs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ohci.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\os.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\scsi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\shell.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\stream.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tcpip.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\telnetd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_cdc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_cdcacm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_hid.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbd_rndis.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbh_hid.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbh_hub.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usbh_uvc.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all_debug</name>
      <member>
        <project>app_blink</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>app_helloworld</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>crc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>debug</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>dhcpc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>dhcpd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>dnsc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>embflash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>fakefat32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>fat</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>file</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>httpc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>httpd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mal</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>malfs</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>os</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>scsi</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>stream</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tcpip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>telnetd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_cdc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_cdcacm</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_hid</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_rndis</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all_release</name>
      <member>
        <project>app_blink</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>app_helloworld</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>crc</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>debug</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>dhcpc</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>dhcpd</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>dnsc</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>embflash</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>fakefat32</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>fat</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>file</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>httpc</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>httpd</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mal</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>malfs</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>os</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>scsi</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>stream</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>tcpip</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>telnetd</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_cdc</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_cdcacm</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_hid</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_msc</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_rndis</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


