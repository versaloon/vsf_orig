# Keil uVision project cmem7.uvproj, settings and files
target M7 (ARM-ADS)
  device: M7 Capital Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: cmem7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __TARGET_CHIP__=cmem7
  c include: ..\Keil_v5_CMEM7;..\..\vsf_cfg;..\..\..\..\compiler\ARMCC;..\..\..\..\interfaces;..\..\..\..\interfaces\cpu\cmem7;..\..\..\..\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group framework
    ../../../../framework/vsfsm/: vsfsm.c vsfsm.h
    ../../../../framework/vsftimer/: vsftimer.c vsftimer.h
    ../../../../framework/vsfshell/: vsfshell.c vsfshell.h
  group interfaces
    ../../../../interfaces/: interfaces.c interfaces.h
    ../../../../interfaces/cpu/cmem7/: core.c core.h interfaces_const.h vsf_basetype.h cmem7.h
    ../../../../interfaces/cpu/cmem7/startup/: startup_cmem7.s
    ../../../../interfaces/cpu/cmem7/usb/: CMEM7_USB.c CMEM7_USB.h
    ../../../../interfaces/cpu/cmem7/usart/: CMEM7_USART.c CMEM7_USART.h
  group stack
    ../../../../stack/usb/core/: vsfusbh.c vsfusbh.h hcd.h
    ../../../../stack/usb/core/dwc_otg/: vsfdwcotg.h
    ../../../../stack/usb/: vsfusb.h
    ../../../../stack/usb/common/: usb_ch9.h usb_ch11.h usb_common.h usb_type.h
    ../../../../stack/usb/class/host/HUB/: vsfusbh_HUB.c vsfusbh_HUB.h
    ../../../../stack/usb/class/host/UVC/: vsfusbh_UVC.c vsfusbh_UVC.h
  group tool
    ../../../../tool/bittool/: bittool.c bittool.h
    ../../../../tool/buffer/: buffer.c buffer.h
    ../../../../tool/list/: list.c list.h
  group app
    ./: app_cfg.h hw_cfg_cmem7.h interfaces_cfg.h
    ../../: app_interfaces.h main.c
    ../../vsf_cfg/: dal_cfg.h vsfsm_cfg.h vsfusbh_cfg.h
  group dal
    ../../../../dal/stream/: stream.c stream.h
    ../../../../dal/usart_stream/: usart_stream.c usart_stream.h
