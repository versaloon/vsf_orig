# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10X_XL; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x0000; CORE_DEBUG=STM32_DBG_JTAG_SWD
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\stm32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: STM32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  ICCARM.CCDefines: NDEBUG; STM32F10X_XL; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x8000; CORE_DEBUG=STM32_DBG_NONE
  OBJCOPY.OOCOutputFile: flash.bin
  group (top)
    ./: app_cfg.h hw_cfg_STM32.h interfaces_cfg.h
    ../../: fakefat32_fs.h httpd_fs.h main.c usbd_desc.h
  group vsf/component/buffer
    ../../../../component/buffer/: buffer.c
  group vsf/component/file
    ../../../../component/file/: vsfile.c
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c
  group vsf/component/file/fs/malfs/fat
    ../../../../component/file/fs/malfs/fat/: vsffat.c
  group vsf/component/list
    ../../../../component/list/: list.c
  group vsf/component/mal
    ../../../../component/mal/: vsfmal.c vsfscsi.c
  group vsf/component/stream
    ../../../../component/stream/: stream.c
  group vsf/framework/vsfshell
    ../../../../framework/vsfshell/: vsfshell.c
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/interfaces
    ../../../../interfaces/: interfaces.c
  group vsf/interfaces/cpu/stm32
    ../../../../interfaces/cpu/stm32/: core.c
  group vsf/interfaces/cpu/stm32/adc
    ../../../../interfaces/cpu/stm32/adc/: STM32_ADC.c
  group vsf/interfaces/cpu/stm32/ebi
    ../../../../interfaces/cpu/stm32/ebi/: STM32_EBI.c
  group vsf/interfaces/cpu/stm32/eint
    ../../../../interfaces/cpu/stm32/eint/: STM32_EINT.c
  group vsf/interfaces/cpu/stm32/flash
    ../../../../interfaces/cpu/stm32/flash/: STM32_FLASH.c
  group vsf/interfaces/cpu/stm32/gpio
    ../../../../interfaces/cpu/stm32/gpio/: STM32_GPIO.c
  group vsf/interfaces/cpu/stm32/sdio
    ../../../../interfaces/cpu/stm32/sdio/: STM32_SDIO.c
  group vsf/interfaces/cpu/stm32/spi
    ../../../../interfaces/cpu/stm32/spi/: STM32_SPI.c
  group vsf/interfaces/cpu/stm32/startup
    ../../../../interfaces/cpu/stm32/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group vsf/interfaces/cpu/stm32/timer
    ../../../../interfaces/cpu/stm32/timer/: STM32_TIM.c
  group vsf/interfaces/cpu/stm32/usart
    ../../../../interfaces/cpu/stm32/usart/: STM32_USART.c
  group vsf/interfaces/cpu/stm32/usbd
    ../../../../interfaces/cpu/stm32/usbd/: STM32_USBD.c
  group vsf/stack/tcpip
    ../../../../stack/tcpip/: vsfip.c
  group vsf/stack/tcpip/netif
    ../../../../stack/tcpip/netif/: vsfip_netif.c
  group vsf/stack/tcpip/netif/eth
    ../../../../stack/tcpip/netif/eth/: vsfip_eth.c
  group vsf/stack/tcpip/proto/dhcp
    ../../../../stack/tcpip/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcpc.c vsfip_dhcpd.c
  group vsf/stack/tcpip/proto/dns
    ../../../../stack/tcpip/proto/dns/: vsfip_dnsc.c
  group vsf/stack/tcpip/proto/http
    ../../../../stack/tcpip/proto/http/: vsfip_httpc.c vsfip_httpd.c
  group vsf/stack/tcpip/proto/telnet
    ../../../../stack/tcpip/proto/telnet/: vsfip_telnetd.c
  group vsf/stack/usb/class/device/CDC
    ../../../../stack/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDCACM.c vsfusbd_RNDIS.c
  group vsf/stack/usb/class/device/MSC
    ../../../../stack/usb/class/device/MSC/: vsfusbd_MSC_BOT.c
  group vsf/stack/usb/core
    ../../../../stack/usb/core/: vsfusbd.c
  group vsf/tool/bittool
    ../../../../tool/bittool/: bittool.c
  group vsf/tool/fakefat32
    ../../../../tool/fakefat32/: fakefat32.c
  group vsf_cfg
    ./: vsf_cfg.h
    ../../vsf_cfg/: vsfip_cfg.h
