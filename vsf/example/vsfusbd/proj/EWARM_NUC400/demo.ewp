# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC400AE series Nuvoton NUC400AE series (NUC442AE,NUC472AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __TARGET_CHIP__=nuc400
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\; ..\..\config; ..\..\..\..\compiler\IAR; ..\..\..\..\hal; ..\..\..\..\hal\cpu\nuc400; ..\..\..\..\hal\cpu\nuc400\core
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: nuc442.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: demo.hex
  group (top)
    ../../: fakefat32_fs.h usrapp.c
  group config
    ./: app_cfg.h hw_cfg_NUC400.h vsfhal_cfg.h
    ../../config/: app_hw_cfg.h vsf_cfg.h
  group vsf
    ../../../../: vsfmain.c
  group vsf/component/fakefat32
    ../../../../component/fakefat32/: fakefat32.c
  group vsf/component/file
    ../../../../component/file/: vsfile.c
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c
  group vsf/component/file/fs/malfs/fat
    ../../../../component/file/fs/malfs/fat/: vsffat.c
  group vsf/component/fundation/bittool
    ../../../../component/fundation/bittool/: bittool.c
  group vsf/component/fundation/buffer
    ../../../../component/fundation/buffer/: buffer.c
  group vsf/component/fundation/stream
    ../../../../component/fundation/stream/: stream.c
  group vsf/component/mal
    ../../../../component/mal/: vsfmal.c vsfscsi.c
  group vsf/component/shell
    ../../../../component/shell/: vsfshell.c
  group vsf/component/tcpip
    ../../../../component/tcpip/: vsfip.c
  group vsf/component/tcpip/netif
    ../../../../component/tcpip/netif/: vsfip_netif.c
  group vsf/component/tcpip/netif/eth
    ../../../../component/tcpip/netif/eth/: vsfip_eth.c
  group vsf/component/tcpip/proto/dhcp
    ../../../../component/tcpip/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcpc.c vsfip_dhcpd.c
  group vsf/component/tcpip/proto/dns
    ../../../../component/tcpip/proto/dns/: vsfip_dnsc.c
  group vsf/component/tcpip/proto/telnet
    ../../../../component/tcpip/proto/telnet/: vsfip_telnetd.c
  group vsf/component/usb/class/device/CDC
    ../../../../component/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDCACM.c vsfusbd_RNDIS.c
  group vsf/component/usb/class/device/MSC
    ../../../../component/usb/class/device/MSC/: vsfusbd_MSC_BOT.c
  group vsf/component/usb/core
    ../../../../component/usb/core/: vsfusbd.c
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/hal
    ../../../../hal/: vsfhal.c
  group vsf/hal/cpu/nuc400
    ../../../../hal/cpu/nuc400/: core.c
  group vsf/hal/cpu/nuc400/gpio
    ../../../../hal/cpu/nuc400/gpio/: NUC400_GPIO.c
  group vsf/hal/cpu/nuc400/startup
    ../../../../hal/cpu/nuc400/startup/IAR/: startup_NUC472_442.s
  group vsf/hal/cpu/nuc400/usbd
    ../../../../hal/cpu/nuc400/usbd/: NUC400_USBD.c
