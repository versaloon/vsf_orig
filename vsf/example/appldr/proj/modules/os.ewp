# IAR project os.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: VSF_STANDALONE_MODULE; MODULE_NAME="vsf.os"; MODULE_INIT=vsfos_modinit; MODULE_EXIT=vsfos_modexit
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\cortex-m
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: MODULE_SIZE=0x8000; MODULE_NAME="vsf.os"
  OBJCOPY.OOCOutputFile: os.bin
  postbuild: wscript "fixsize.vbs" "$EXE_DIR$\$PROJ_FNAME$.bin"
  ILINK.IlinkOutputFile: os.out
  ILINK.IlinkIcfFile: module.icf
  ILINK.IlinkProgramEntryLabel: module_entry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; VSF_STANDALONE_MODULE; MODULE_NAME="vsf.os"; MODULE_INIT=vsfos_modinit; MODULE_EXIT=vsfos_modexit
  group (top)
    ./: app_cfg.h interfaces_cfg.h vsf_cfg.h
    ../../: app_hw_cfg.h
    ../../module/: modmain.c
    ../../module/vsfos/: vsfos.c vsfos_busybox.c
  group vsf/interfaces/cpu/cortex-m/startup
    ../../../../interfaces/cpu/cortex-m/startup/iar/: startup.s
