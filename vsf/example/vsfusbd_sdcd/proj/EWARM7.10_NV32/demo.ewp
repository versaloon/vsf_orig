# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NV32F100x Navota NV32F100x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __TARGET_CHIP__=nv32; FLASH_LOAD_OFFSET=0x00000000; IAR; CPU_NV32
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\nv32
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: nv32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; __TARGET_CHIP__=nv32; FLASH_LOAD_OFFSET=0x00000000
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: GD32F130x8.icf
  group (top)
    ../../: usrapp.c
  group cfg
    ./: app_cfg.h app_hw_cfg.h hw_cfg_NV32.h interfaces_cfg.h vsf_cfg.h
  group vsf
    ../../../../: vsfmain.c
  group vsf/component/buffer
    ../../../../component/buffer/: buffer.c
  group vsf/component/stream
    ../../../../component/stream/: stream.c
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/interfaces
    ../../../../interfaces/: interfaces.c
  group vsf/interfaces/cpu/nv32
    ../../../../interfaces/cpu/nv32/: core.c
  group vsf/interfaces/cpu/nv32/driver/ics
    ../../../../interfaces/cpu/nv32/driver/ics/: ics.c
  group vsf/interfaces/cpu/nv32/driver/vector
    ../../../../interfaces/cpu/nv32/driver/vector/: vectors.c
  group vsf/interfaces/cpu/nv32/gpio
    ../../../../interfaces/cpu/nv32/gpio/: NV32_GPIO.c
  group vsf/interfaces/cpu/nv32/usbdio
    ../../../../interfaces/cpu/nv32/usbdio/: NV32_USBDIO.c USBDIO.s
  group vsf/stack/usb/class/device/CDC
    ../../../../stack/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDCACM.c
  group vsf/stack/usb/common
    ../../../../stack/usb/common/: usb_common.c
  group vsf/stack/usb/core
    ../../../../stack/usb/core/: vsfusbd.c
  group vsf/stack/usb/core/dcd/sdcd
    ../../../../stack/usb/core/dcd/sdcd/: vsfsdcd.c
  group vsf/tool/bittool
    ../../../../tool/bittool/: bittool.c
