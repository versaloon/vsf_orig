# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F130x8 GD GD32F130x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __TARGET_CHIP__=gd32f1x0; FLASH_LOAD_OFFSET=0x08000000
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\gd32f1x0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: GD32F130x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; __TARGET_CHIP__=gd32f1x0; FLASH_LOAD_OFFSET=0x08000000
  group (top)
    ../../: usrapp.c
  group cfg
    ./: app_cfg.h app_hw_cfg.h hw_cfg_GD32.h interfaces_cfg.h vsf_cfg.h
  group vsf
    ../../../../: vsfmain.c
  group vsf/component/buffer
    ../../../../component/buffer/: buffer.c
  group vsf/component/stream
    ../../../../component/stream/: stream.c
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/interfaces
    ../../../../interfaces/: interfaces.c
  group vsf/interfaces/cpu/gd32f1x0
    ../../../../interfaces/cpu/gd32f1x0/: core.c
  group vsf/interfaces/cpu/gd32f1x0/gpio
    ../../../../interfaces/cpu/gd32f1x0/gpio/: GD32F1X0_GPIO.c
  group vsf/interfaces/cpu/gd32f1x0/startup
    ../../../../interfaces/cpu/gd32f1x0/startup/iar/: startup_gd32f1x0.s
  group vsf/interfaces/cpu/gd32f1x0/usbd
    ../../../../interfaces/cpu/gd32f1x0/usbd/: GD32F1X0_USBD.c
  group vsf/interfaces/cpu/gd32f1x0/usbdio
    ../../../../interfaces/cpu/gd32f1x0/usbdio/: GD32F1X0_USBDIO.c
  group vsf/stack/usb/class/device/CDC
    ../../../../stack/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDCACM.c
  group vsf/stack/usb/common
    ../../../../stack/usb/common/: usb_common.c
  group vsf/stack/usb/core
    ../../../../stack/usb/core/: vsfusbd.c
  group vsf/stack/usb/core/dcd/sdcd
    ../../../../stack/usb/core/dcd/sdcd/: vsfsdcd.c
  group vsf/tool/bittool
    ../../../../tool/bittool/: bittool.c
