# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_XL; __TARGET_CHIP__=gd32f1x0; FLASH_LOAD_OFFSET=0x0000
  ICCARM.CCIncludePath2: ; ..\..; ..\..\config; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\hal; ..\..\..\..\..\vsf\hal\cpu\gd32f1x0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: GD32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZC ST STM32F103ZC
  ICCARM.CCDefines: NDEBUG; STM32F10X_XL; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x8000; CORE_DEBUG=STM32_DBG_NONE
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\stm32
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkIcfFile: STM32.icf
  group (top)
    ../../: fakefat32_fs.h usrapp.c
  group config
    ./: app_cfg.h hw_cfg_GD32.h vsfhal_cfg.h
    ../../config/: app_hw_cfg.h vsf_cfg.h
  group vsf
    ../../../../: vsfmain.c
  group vsf/component/fakefat32
    ../../../../component/fakefat32/: fakefat32.c
  group vsf/component/file
    ../../../../component/file/: vsfile.c
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c
  group vsf/component/file/fs/malfs/fat
    ../../../../component/file/fs/malfs/fat/: vsffat.c
  group vsf/component/fundation/bittool
    ../../../../component/fundation/bittool/: bittool.c
  group vsf/component/fundation/buffer
    ../../../../component/fundation/buffer/: buffer.c
  group vsf/component/fundation/stream
    ../../../../component/fundation/stream/: stream.c
  group vsf/component/mal
    ../../../../component/mal/: vsfmal.c vsfscsi.c
  group vsf/component/shell
    ../../../../component/shell/: vsfshell.c
  group vsf/component/tcpip
    ../../../../component/tcpip/: vsfip.c
  group vsf/component/tcpip/netif
    ../../../../component/tcpip/netif/: vsfip_netif.c
  group vsf/component/tcpip/netif/eth
    ../../../../component/tcpip/netif/eth/: vsfip_eth.c
  group vsf/component/tcpip/proto/dhcp
    ../../../../component/tcpip/proto/dhcp/: vsfip_dhcp_common.c vsfip_dhcpc.c vsfip_dhcpd.c
  group vsf/component/tcpip/proto/dns
    ../../../../component/tcpip/proto/dns/: vsfip_dnsc.c
  group vsf/component/tcpip/proto/telnet
    ../../../../component/tcpip/proto/telnet/: vsfip_telnetd.c
  group vsf/component/usb/class/device/CDC
    ../../../../component/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDCACM.c vsfusbd_RNDIS.c
  group vsf/component/usb/class/device/MSC
    ../../../../component/usb/class/device/MSC/: vsfusbd_MSC_BOT.c
  group vsf/component/usb/core
    ../../../../component/usb/core/: vsfusbd.c
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/hal
    ../../../../hal/: vsfhal.c
  group vsf/hal/cpu/gd32
    ../../../../hal/cpu/gd32f1x0/: core.c
  group vsf/hal/cpu/gd32/flash
    ../../../../hal/cpu/gd32f1x0/flash/: GD32F1X0_FLASH.c
  group vsf/hal/cpu/gd32/gpio
    ../../../../hal/cpu/gd32f1x0/gpio/: GD32F1X0_GPIO.c
  group vsf/hal/cpu/gd32/startup
    ../../../../hal/cpu/gd32f1x0/startup/iar/: startup_gd32f1x0.s
  group vsf/hal/cpu/gd32/usbd
    ../../../../hal/cpu/gd32f1x0/usbd/: GD32F1X0_USBD.c
