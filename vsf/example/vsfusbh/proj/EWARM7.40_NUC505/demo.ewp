# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC505 series Nuvoton NUC505 series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __TARGET_CHIP__=nuc505; FLASH_LOAD_OFFSET=0x0000
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..; ..\..\..\..\compiler\IAR; ..\..\..\..\interfaces; ..\..\..\..\interfaces\cpu\nuc505; ..\..\..\..\interfaces\cpu\nuc505\core
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: NUC505.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32F10X_XL; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x8000; CORE_DEBUG=STM32_DBG_NONE
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\stm32
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: flash.bin
  ILINK.IlinkIcfFile: STM32.icf
  group (top)
    ./: app_cfg.h hw_cfg_nuc505.h interfaces_cfg.h vsf_cfg.h
    ../../: main.c
  group vsf/component/buffer
    ../../../../component/buffer/: buffer.c buffer.h
  group vsf/component/debug
    ../../../../component/debug/: debug.c debug.h
  group vsf/component/file
    ../../../../component/file/: vsfile.c
  group vsf/component/file/fs/malfs
    ../../../../component/file/fs/malfs/: vsf_malfs.c
  group vsf/component/list
    ../../../../component/list/: list.c list.h
  group vsf/component/mal
    ../../../../component/mal/: vsfmal.c vsfscsi.c
  group vsf/component/stream
    ../../../../component/stream/: stream.c stream.h
  group vsf/framework/vsfshell
    ../../../../framework/vsfshell/: vsfshell.c vsfshell.h
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/interfaces
    ../../../../interfaces/: interfaces.c
  group vsf/interfaces/cpu/nuc505
    ../../../../interfaces/cpu/nuc505/: core.c core.h interfaces_const.h NUC505Series.h vsf_basetype.h
  group vsf/interfaces/cpu/nuc505/core
    ../../../../interfaces/cpu/nuc505/core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group vsf/interfaces/cpu/nuc505/gpio
    ../../../../interfaces/cpu/nuc505/gpio/: NUC505_GPIO.c NUC505_GPIO.h
  group vsf/interfaces/cpu/nuc505/ohci
    ../../../../interfaces/cpu/nuc505/ohci/: NUC505_OHCI.c NUC505_OHCI.h
  group vsf/interfaces/cpu/nuc505/startup
    ../../../../interfaces/cpu/nuc505/startup/IAR/: startup_NUC505Series.s
  group vsf/interfaces/cpu/nuc505/usbd
    ../../../../interfaces/cpu/nuc505/usbd/: NUC505_USBD.c NUC505_USBD.h
  group vsf/stack/usb/class/device/CDC
    ../../../../stack/usb/class/device/CDC/: vsfusbd_CDC.c vsfusbd_CDC.h vsfusbd_CDCACM.c vsfusbd_CDCACM.h
  group vsf/stack/usb/class/host/HID
    ../../../../stack/usb/class/host/HID/: vsfusbh_HID.c vsfusbh_HID.h
  group vsf/stack/usb/class/host/HUB
    ../../../../stack/usb/class/host/HUB/: vsfusbh_HUB.c vsfusbh_HUB.h
  group vsf/stack/usb/class/host/MSC
    ../../../../stack/usb/class/host/MSC/: vsfusbh_MSC.c
  group vsf/stack/usb/class/host/UVC
    ../../../../stack/usb/class/host/UVC/: vsfusbh_UVC.c vsfusbh_UVC.h
  group vsf/stack/usb/common
    ../../../../stack/usb/common/: usb_ch11.h usb_ch9.h usb_common.h usb_type.h
  group vsf/stack/usb/core
    ../../../../stack/usb/core/: vsfusbd.c vsfusbd.h vsfusbh.c vsfusbh.h
  group vsf/stack/usb/core/hcd/ohci
    ../../../../stack/usb/core/hcd/ohci/: vsfohci.c vsfohci.h vsfohci_priv.h
  group vsf/tool/bittool
    ../../../../tool/bittool/: bittool.c
